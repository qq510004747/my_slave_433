# Keil uVision project project.uvprojx, settings and files
target STM32F10x工程摸板2.0.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\J_LINK_RTT\RTT;..\User;..\BSP\BSP;..\BSP\BSP_InPut;..\BSP\BSP_OutPut;..\BSP\BSP_FLASH;..\BSP\BSP_USART;..\Libraries\FreeRTOS;..\Libraries\FreeRTOS\include;..\Libraries\FreeRTOS\FreeRTOSConfig;..\Libraries\FreeRTOS\portable\RVDS\ARM_CM3;..\BSP\OLED;..\BSP;..\BSP\OLED;..\BSP\TIMER3;..\BSP\BSP_Switch;..\BSP\BSP_USART1;..\BSP\BSP_Internet\W5500;..\BSP\SX1278\radio;..\BSP\SX1278\platform\sx12xxEiger;..\BSP\SX1278\platform;..\BSP\apps;..\BSP\BSP_FIFO;..\BSP\crc;..\BSP\ADC;..\BSP\BSP_USART3;..\BSP\E31radio_driver;..\BSP\TIMER2;..\BSP\BSP_USART2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c AppTask.c Utility.c
    ../Libraries/FreeRTOS/FreeRTOSConfig/: FreeRTOSConfig.h RTOS_Config.h
    ../BSP/BSP/: BSP.h
  group BSP
    ../BSP/BSP/: BSP.C
    ../BSP/BSP_Switch/: BSP_Switch.c
    ../BSP/BSP_OutPut/: BSP_OutPut.C
    ../BSP/BSP_InPut/: BSP_InPut.c
    ../BSP/BSP_FIFO/: BSP_FIFO.c
    ../BSP/BSP_USART1/: BSP_USART1.C
    ../BSP/crc/: crc.c
    ../BSP/TIMER3/: TIMER3.c
    ../BSP/ADC/: ADC.c
    ../BSP/E31radio_driver/: radio_driver.c
    ../BSP/TIMER2/: TIMER2.c
    ../BSP/BSP_USART2/: BSP_USART2.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd_FreeRTOS.s
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c
  group FreeRTOS
    ../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Libraries/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Libraries/FreeRTOS/portable/MemMang/: heap_4.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group Doc
    ./: Readme.txt
  group Internet
    ../BSP/BSP_Internet/W5500/: w5500.c W5500_Conf.c W5500_Socket.c W5500_SPI.c
  group lora
    ../BSP/SX1278/platform/sx12xxEiger/: spi.c sx12xxEiger.c sx1276-Hal.c
  group radio
    ../BSP/SX1278/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group apps
    ../BSP/apps/: RF.c TCP.c mesh.c Inout_Handle.c
